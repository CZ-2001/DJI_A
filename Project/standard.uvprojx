# Keil uVision project standard.uvprojx, settings and files
target standard (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: standard +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_STDPERIPH_DRIVER
  c include: ..\Libaries\CMSIS;..\Libaries\FWLIB\inc;..\Libaries;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Libaries\startup;..\Libaries\DSP\Include;..\main;..\Mylib\AHRS;..\Mylib;..\APP;..\Tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Libaries
    ../Libaries/startup/: startup_stm32f427xx.s
    ../Libaries/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
    ../Libaries/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group freeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Libaries/: FreeRTOS_middleware.c
  group AHRS
    ../Mylib/AHRS/: AHRS.lib AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c
  group main
    ../main/: main.c
  group hardware
    ../Mylib/: adc.c buzzer.c can.c dac.c delay.c exit_init.c flash.c laser.c led.c power_ctrl.c rc.c rng.c spi.c sys.c timer.c user_lib.c remote_control.c func_lib.c uart_vofa.c icm20602.c usart_judge.c usart6_vision.c mag_pwm.c key_button.c
  group APP
    ../APP/: pid.c can_rec.c chassis_behaviour.c gimbal_behaviour.c function.c shoot_behaviour.c vision_behaviour.c judge_behaviour.c UI_behaviour.c check_crc.c
  group Tasks
    ../Tasks/: start_task.c user_task.c rc_task.c vofa_task.c calibrate_task.c INS_task.c chassis_task.c gimbal_task.c shoot_task.c icm20602_task.c UI_Send_task.c
  group HELPS
    ./: judge_code_help.txt
    ../: 更新日志.txt
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
